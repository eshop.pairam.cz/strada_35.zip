Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: strada 35.IFC
Time: 2021-03-15T14:08:29
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: strada 35
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
